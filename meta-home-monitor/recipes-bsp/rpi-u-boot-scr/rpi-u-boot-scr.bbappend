# Override default boot script with A/B partition switching (ADR-0008)
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
